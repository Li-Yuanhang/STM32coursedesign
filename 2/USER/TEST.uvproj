# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
